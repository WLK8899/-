# Keil uVision project stm32F407_study.uvprojx, settings and files
target stm32F407_study (6210000::V6.21::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32F407_study +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../HardWare/motor;../MY/contor;../MY/system;../HardWare/sys;../HardWare/oled;../MY/MPU6050;../FreeRTOS/include;../FreeRTOS/portable/GCC/ARM_CM4F;../MY/uart5
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group HardWare
    ../HardWare/motor/: motor.c
    ../HardWare/sys/: sys.c
    ../HardWare/oled/: oled.c
  group MY
    ../MY/contor/: contor.c
    ../MY/system/: system.c
    ../MY/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c MPU6050.c
    ./: uart5.c
  group freeRTOS_core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group freeRTOS_port
    ../FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.6.0
